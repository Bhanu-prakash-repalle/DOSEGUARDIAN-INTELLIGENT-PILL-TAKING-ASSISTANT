# Keil uVision project mini_pro.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2129 NXP
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: mini_pro1 +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Source Group 1
    ./: Startup.s delay.c lcd.c keypadfun1.c rtc.c rtc_main.c tim_dat.c
